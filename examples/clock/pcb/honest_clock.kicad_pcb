# Repository djacobow/noscheme (continued)

## KiCad design examples/clock/pcb/honest_clock.kicad_pcb (continued)

Schematic: display_Digit.kicad_sch, display.Digit

Parts:
C73: 100nF; C_0603_1608Metric
DS1: LSHD-5601; 7SegmentLED_LTS6760_LTS6780; MPN LSHD-5601
R47: 1.8kOhm; R_0603_1608Metric
U26: TLC5916IDR; SOIC-16_3.9x9.9mm_P1.27mm; MPN TLC5916IDR

Connections:
/leds.blank#: U26.13 (~OE(ED2)); also elsewhere on the board
/leds.clock: U26.3 (CLK); also elsewhere on the board
/leds.data_in: U26.2 (SDI); also elsewhere on the board
/leds.latch: U26.4 (LE(ED1)); also elsewhere on the board
/time_display/digits[0]/current_set: R47.1, U26.15 (R-EXT)
/time_display/digits[0]/segments[0]: DS1.10 (g), U26.5 (~OUT0)
/time_display/digits[0]/segments[1]: DS1.9 (f), U26.6 (~OUT1)
/time_display/digits[0]/segments[2]: DS1.7 (a), U26.7 (~OUT2)
/time_display/digits[0]/segments[3]: DS1.6 (b), U26.8 (~OUT3)
/time_display/digits[0]/segments[4]: DS1.5 (dp), U26.9 (~OUT4)
/time_display/digits[0]/segments[5]: DS1.4 (c), U26.10 (~OUT5)
/time_display/digits[0]/segments[6]: DS1.2 (d), U26.11 (~OUT6)
/time_display/digits[0]/segments[7]: DS1.1 (e), U26.12 (~OUT7)
/time_display/link[0]: U26.14 (SDO); also elsewhere on the board
gnd: C73.2, R47.2, U26.1 (GND); also elsewhere on the board
v3v3: C73.1, U26.16 (VDD); also elsewhere on the board
v5: DS1.3, DS1.8; also elsewhere on the board

Parts of its further copies:
C74, C75, C76, C77, C78, C79, C80, C81: 100nF; C_0603_1608Metric
DS2, DS3, DS4, DS5, DS6, DS7, DS8, DS9: LSHD-5601; 7SegmentLED_LTS6760_LTS6780; MPN LSHD-5601
R48, R49, R50, R51, R52, R53, R54, R55: 1.8kOhm; R_0603_1608Metric
U27, U28, U29, U30, U31, U32, U33, U34: TLC5916IDR; SOIC-16_3.9x9.9mm_P1.27mm; MPN TLC5916IDR

Connections of its further copies:
/leds.blank#: U27.13 (~OE(ED2)), U28.13 (~OE(ED2)), U29.13 (~OE(ED2)), U30.13 (~OE(ED2)), U31.13 (~OE(ED2)), U32.13 (~OE(ED2)), U33.13 (~OE(ED2)), U34.13 (~OE(ED2)); also elsewhere on the board
/leds.clock: U27.3 (CLK), U28.3 (CLK), U29.3 (CLK), U30.3 (CLK), U31.3 (CLK), U32.3 (CLK), U33.3 (CLK), U34.3 (CLK); also elsewhere on the board
/leds.data_out: U34.14 (SDO); also elsewhere on the board
/leds.latch: U27.4 (LE(ED1)), U28.4 (LE(ED1)), U29.4 (LE(ED1)), U30.4 (LE(ED1)), U31.4 (LE(ED1)), U32.4 (LE(ED1)), U33.4 (LE(ED1)), U34.4 (LE(ED1)); also elsewhere on the board
/time_display/digits[1]/current_set: R48.1, U27.15 (R-EXT)
/time_display/digits[1]/segments[0]: DS2.10 (g), U27.5 (~OUT0)
/time_display/digits[1]/segments[1]: DS2.9 (f), U27.6 (~OUT1)
/time_display/digits[1]/segments[2]: DS2.7 (a), U27.7 (~OUT2)
/time_display/digits[1]/segments[3]: DS2.6 (b), U27.8 (~OUT3)
/time_display/digits[1]/segments[4]: DS2.5 (dp), U27.9 (~OUT4)
/time_display/digits[1]/segments[5]: DS2.4 (c), U27.10 (~OUT5)
/time_display/digits[1]/segments[6]: DS2.2 (d), U27.11 (~OUT6)
/time_display/digits[1]/segments[7]: DS2.1 (e), U27.12 (~OUT7)
/time_display/digits[2]/current_set: R49.1, U28.15 (R-EXT)
/time_display/digits[2]/segments[0]: DS3.10 (g), U28.5 (~OUT0)
/time_display/digits[2]/segments[1]: DS3.9 (f), U28.6 (~OUT1)
/time_display/digits[2]/segments[2]: DS3.7 (a), U28.7 (~OUT2)
/time_display/digits[2]/segments[3]: DS3.6 (b), U28.8 (~OUT3)
/time_display/digits[2]/segments[4]: DS3.5 (dp), U28.9 (~OUT4)
/time_display/digits[2]/segments[5]: DS3.4 (c), U28.10 (~OUT5)
/time_display/digits[2]/segments[6]: DS3.2 (d), U28.11 (~OUT6)
/time_display/digits[2]/segments[7]: DS3.1 (e), U28.12 (~OUT7)
/time_display/digits[3]/current_set: R50.1, U29.15 (R-EXT)
/time_display/digits[3]/segments[0]: DS4.10 (g), U29.5 (~OUT0)
/time_display/digits[3]/segments[1]: DS4.9 (f), U29.6 (~OUT1)
/time_display/digits[3]/segments[2]: DS4.7 (a), U29.7 (~OUT2)
/time_display/digits[3]/segments[3]: DS4.6 (b), U29.8 (~OUT3)
/time_display/digits[3]/segments[4]: DS4.5 (dp), U29.9 (~OUT4)
/time_display/digits[3]/segments[5]: DS4.4 (c), U29.10 (~OUT5)
/time_display/digits[3]/segments[6]: DS4.2 (d), U29.11 (~OUT6)
/time_display/digits[3]/segments[7]: DS4.1 (e), U29.12 (~OUT7)
/time_display/digits[4]/current_set: R51.1, U30.15 (R-EXT)
/time_display/digits[4]/segments[0]: DS5.10 (g), U30.5 (~OUT0)
/time_display/digits[4]/segments[1]: DS5.9 (f), U30.6 (~OUT1)
/time_display/digits[4]/segments[2]: DS5.7 (a), U30.7 (~OUT2)
/time_display/digits[4]/segments[3]: DS5.6 (b), U30.8 (~OUT3)
/time_display/digits[4]/segments[4]: DS5.5 (dp), U30.9 (~OUT4)
/time_display/digits[4]/segments[5]: DS5.4 (c), U30.10 (~OUT5)
/time_display/digits[4]/segments[6]: DS5.2 (d), U30.11 (~OUT6)
/time_display/digits[4]/segments[7]: DS5.1 (e), U30.12 (~OUT7)
/time_display/digits[5]/current_set: R52.1, U31.15 (R-EXT)
/time_display/digits[5]/segments[0]: DS6.10 (g), U31.5 (~OUT0)
/time_display/digits[5]/segments[1]: DS6.9 (f), U31.6 (~OUT1)
/time_display/digits[5]/segments[2]: DS6.7 (a), U31.7 (~OUT2)
/time_display/digits[5]/segments[3]: DS6.6 (b), U31.8 (~OUT3)
/time_display/digits[5]/segments[4]: DS6.5 (dp), U31.9 (~OUT4)
/time_display/digits[5]/segments[5]: DS6.4 (c), U31.10 (~OUT5)
/time_display/digits[5]/segments[6]: DS6.2 (d), U31.11 (~OUT6)
/time_display/digits[5]/segments[7]: DS6.1 (e), U31.12 (~OUT7)
/time_display/digits[6]/current_set: R53.1, U32.15 (R-EXT)
/time_display/digits[6]/segments[0]: DS7.10 (g), U32.5 (~OUT0)
/time_display/digits[6]/segments[1]: DS7.9 (f), U32.6 (~OUT1)
/time_display/digits[6]/segments[2]: DS7.7 (a), U32.7 (~OUT2)
/time_display/digits[6]/segments[3]: DS7.6 (b), U32.8 (~OUT3)
/time_display/digits[6]/segments[4]: DS7.5 (dp), U32.9 (~OUT4)
/time_display/digits[6]/segments[5]: DS7.4 (c), U32.10 (~OUT5)
/time_display/digits[6]/segments[6]: DS7.2 (d), U32.11 (~OUT6)
/time_display/digits[6]/segments[7]: DS7.1 (e), U32.12 (~OUT7)
/time_display/digits[7]/current_set: R54.1, U33.15 (R-EXT)
/time_display/digits[7]/segments[0]: DS8.10 (g), U33.5 (~OUT0)
/time_display/digits[7]/segments[1]: DS8.9 (f), U33.6 (~OUT1)
/time_display/digits[7]/segments[2]: DS8.7 (a), U33.7 (~OUT2)
/time_display/digits[7]/segments[3]: DS8.6 (b), U33.8 (~OUT3)
/time_display/digits[7]/segments[4]: DS8.5 (dp), U33.9 (~OUT4)
/time_display/digits[7]/segments[5]: DS8.4 (c), U33.10 (~OUT5)
/time_display/digits[7]/segments[6]: DS8.2 (d), U33.11 (~OUT6)
/time_display/digits[7]/segments[7]: DS8.1 (e), U33.12 (~OUT7)
/time_display/digits[8]/current_set: R55.1, U34.15 (R-EXT)
/time_display/digits[8]/segments[0]: DS9.10 (g), U34.5 (~OUT0)
/time_display/digits[8]/segments[1]: DS9.9 (f), U34.6 (~OUT1)
/time_display/digits[8]/segments[2]: DS9.7 (a), U34.7 (~OUT2)
/time_display/digits[8]/segments[3]: DS9.6 (b), U34.8 (~OUT3)
/time_display/digits[8]/segments[4]: DS9.5 (dp), U34.9 (~OUT4)
/time_display/digits[8]/segments[5]: DS9.4 (c), U34.10 (~OUT5)
/time_display/digits[8]/segments[6]: DS9.2 (d), U34.11 (~OUT6)
/time_display/digits[8]/segments[7]: DS9.1 (e), U34.12 (~OUT7)
/time_display/link[0]: U27.2 (SDI); also elsewhere on the board
/time_display/link[1]: U27.14 (SDO), U28.2 (SDI)
/time_display/link[2]: U28.14 (SDO), U29.2 (SDI)
/time_display/link[3]: U29.14 (SDO), U30.2 (SDI)
/time_display/link[4]: U30.14 (SDO), U31.2 (SDI)
/time_display/link[5]: U31.14 (SDO), U32.2 (SDI)
/time_display/link[6]: U32.14 (SDO), U33.2 (SDI)
/time_display/link[7]: U33.14 (SDO), U34.2 (SDI)
gnd: C74.2, C75.2, C76.2, C77.2, C78.2, C79.2, C80.2, C81.2, R48.2, R49.2, R50.2, R51.2, R52.2, R53.2, R54.2, R55.2, U27.1 (GND), U28.1 (GND), U29.1 (GND), U30.1 (GND), U31.1 (GND), U32.1 (GND), U33.1 (GND), U34.1 (GND); also elsewhere on the board
v3v3: C74.1, C75.1, C76.1, C77.1, C78.1, C79.1, C80.1, C81.1, U27.16 (VDD), U28.16 (VDD), U29.16 (VDD), U30.16 (VDD), U31.16 (VDD), U32.16 (VDD), U33.16 (VDD), U34.16 (VDD); also elsewhere on the board
v5: DS2.3, DS2.8, DS3.3, DS3.8, DS4.3, DS4.8, DS5.3, DS5.8, DS6.3, DS6.8, DS7.3, DS7.8, DS8.3, DS8.8, DS9.3, DS9.8; also elsewhere on the board

Board: 4 copper layers, 184 parts (148 on the bottom side), 186 nets, no tracks yet.

Other parts of the board:
H1, H2, H3, H4, H5: MountingHole_3.2mm_M3
